Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-06-30T08:41:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 30 08:41:35 2022 * Host: SPOJAR-RO-LE * Database: C:\Users\spojar\AppData\Local\Temp\25db43d7-9fbb-4866-805c-4fef5fdc234c\9f7d3224-dbc5-4315-b51a-5fd060153e65\ifc * Database version: 5507 * Database creation date: Thu Jun 30 08:41:33 2022 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Jun 30 08:41:34 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 30 08:41:34 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_BuildingStoreyCommon - Reference: Level 1
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcBoiler: Ilea 18-25, HC_Boiler_Condensate Flow_MEPcontent_ACV_Ilea 18-30_BE-EN:Ilea 18-25:10886
In: Level 1
Type - Material: Color RGB 040-040-040, Color RGB 237-028-036, Color RGB 143-146-144, Color RGB 222-222-222, Color RGB 187-080-046, Color RGB 129-158-173
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Air Supply Diameter: 100 mm; Depth: 316 mm; Domestic Cold Water Connection Diameter: 12.7 mm; Domestic Hot Water Diameter: 12.7 mm; Drain Connection Diameter: 16 mm; Flue Gas Diameter: 60 mm; Gas Diameter: 19.05 mm; Height: 756 mm; Hydronic Return Diameter: 19.05 mm; Hydronic Supply Diameter: 19.05 mm; Use Nominal Diameter: yes; Width: 400 mm
Type - Electrical - Class: 6; Current: 0 A; Frequency: 0 Hz; Hertz: 50 Hz; Power: 120 W; Rated Current (Fuse): 10 A; Voltage: 230 V
Type - Identity Data - Article Description: Stainless steel wall mounted gas condensing boiler; Article Type: Ilea 18/25; Base Family Version: 22.07; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Stainless steel wall mounted gas condensing boiler; EMCS Version: 4.0; ETIM Article Class: EC010232; Family Version: 22.07; GTIN: 5400891040645; Manufacturer: ACV; Manufacturer Art. No.: A1006860; Manufacturer URL: https://www.acv.com/belgique/dl/8050; MEPcontent Class: BOILER_CONDENSATE_FLOW; Model: Ilea 18/25; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: Ilea; Revit Version: 2019; Type Name: Ilea 18-25; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Blue: Color RGB 129-158-173; Dark Grey: Color RGB 080-080-080; Light Grey: Color RGB 143-146-144; Orange: Color RGB 187-080-046; Red: Color RGB 237-028-036; White: Color RGB 222-222-222
Type - Mechanical - DHW Continuous Flow 60°C: 0.00441433 m3/s; Input: 28900 W; Maximum Supply Temperature (Operating Temperature): 85 kg/K/s3; Max Power Boiler: 18800 W; Max Pressure Heating: 300000 Pa; Min Power Boiler: 3400 W; Total Capacity: 0.003 m3; Weight: 29.5
Type - Other - Category: Mechanical Equipment; Chimney Agreement: C13-C33-C53-C93-B23P-B23-C43P-C83-C83P; Depth safe: 316.5 mm; Family Name: HC_Boiler_Condensate Flow_MEPcontent_ACV_Ilea 18-30_BE-EN; Height Safe: 758.6 mm; Left Clearance Safe: 0 mm; Nominal Diameter: 19.05 mm; Outer Diameter: 26.9 mm; Right Clearance Safe: 0 mm; Space Heating Energy Efficiency Class: A; Width Safe: 400 mm
Type - Text - Pipe Type Category: M561
Type - Pset_BoilerTypeCommon - Reference: Ilea 18-25
Type - Pset_EnvironmentalImpactIndicators - Reference: Ilea 18-25
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACV
Pset_BoilerTypeCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 3.03988 m2; Volume: 0.0817764 m3
Identity Data - Mark: 1
Mechanical - Air Supply Flow: 0 m3/s; Domestic Cold Water Flow: 0 m3/s; Domestic Hot Water Flow: 0 m3/s; Drain Fixture Units: 0; Flue Gas Flow: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; System Classification: Hydronic Return,Domestic Cold Water,Undefined,Domestic Hot Water,Hydronic Supply,Sanitary,Power,Other
Other - Bottom Clerance Safe: 200 mm; Family: HC_Boiler_Condensate Flow_MEPcontent_ACV_Ilea 18-30_BE-EN: Ilea 18-25; Family and Type: HC_Boiler_Condensate Flow_MEPcontent_ACV_Ilea 18-30_BE-EN: Ilea 18-25; Front Clearance Safe: 700 mm; Top Clearance Safe: 220 mm; Type: HC_Boiler_Condensate Flow_MEPcontent_ACV_Ilea 18-30_BE-EN: Ilea 18-25; Type Id: HC_Boiler_Condensate Flow_MEPcontent_ACV_Ilea 18-30_BE-EN: Ilea 18-25
Phasing - Phase Created: New Construction
Visibility - Bottom Clerance: 200 mm; Front Clearance: 700 mm; Service Space: no; Top Clearance: 220 mm

# IfcDistributionPort (9)
Description: Flow
Name | FlowDirection
4 x Port_10886 | SINK
4 x Port_10886 | SOURCE
Port_10886 | SOURCEANDSINK
